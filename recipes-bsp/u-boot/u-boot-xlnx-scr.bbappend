KERNEL_COMMAND_APPEND:append:system-controller = "uio_pdrv_genirq.of_id=generic-uio"
