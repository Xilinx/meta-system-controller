BASECAMP_IMAGE_FULL_INSTALL += "python3-frugy"
