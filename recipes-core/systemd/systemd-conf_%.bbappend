FILESEXTRAPATHS:prepend:eval-brd-sc-zynqmp := "${THISDIR}/${PN}:"

